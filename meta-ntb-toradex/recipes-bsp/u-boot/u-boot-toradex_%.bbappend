FILESEXTRAPATHS_prepend := "${THISDIR}/${PN}:"

SRC_URI += "file://uboot-dtb.patch"
