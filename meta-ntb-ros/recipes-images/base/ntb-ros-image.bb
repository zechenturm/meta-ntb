require recipes-images/base/ntb-image-base.bb
require recipes-core/images/ros-image-core.bb
