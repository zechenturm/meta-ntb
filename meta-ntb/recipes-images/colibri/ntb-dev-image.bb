require recipes-images/colibri/ntb-image-common.inc